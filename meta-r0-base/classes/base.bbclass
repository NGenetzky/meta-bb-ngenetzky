# This is bblcass is provided by bitbake as a starting point.
inherit bb_base

inherit bb_oe_import
inherit bb_oe_base
