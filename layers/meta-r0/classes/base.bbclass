# This is bblcass is provided by bitbake as a starting point.
inherit bb_base